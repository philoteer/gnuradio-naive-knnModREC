<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>signal_separator</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>BW</value></param>
<param><key>value</key><value>samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>capture_now</value></param>
<param><key>comment</key><value>GUI button</value></param>
<param><key>value</key><value>0</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim_factor</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>detection_min_bw</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>energy_threshold</value></param>
<param><key>value</key><value>noise_lvl + 10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size_sig0</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_path</value></param>
<param><key>value</key><value>"./feature.csv"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>freq_M*1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_M</value></param>
<param><key>value</key><value>190</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>50</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mul</value></param>
<param><key>value</key><value>32767</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_avg</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>noise_lvl</value></param>
<param><key>block_id</key><value>noise_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>samp_rate_M*1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samp_rate_M</value></param>
<param><key>value</key><value>25</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sig0_avg_pts</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>sig0_p</value></param>
<param><key>block_id</key><value>sig0_p_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sig0_p2</value></param>
<param><key>value</key><value>sig0_p if sig0_p != 0 else 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sig0_power_avg</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>signal_name</value></param>
<param><key>value</key><value>""</value></param>
<param><key>label</key><value>signal_name</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transient_pts</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>noise_lvl</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0_0</value></param>
<param><key>vlen</key><value>fft_size_sig0/2</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0</value></param>
<param><key>decim</key><value>fft_size_sig0/2 * sig0_power_avg</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size_sig0/4</value></param>
</block>
<block>
<key>blocks_max_xx</key>
<param><key>id</key><value>blocks_max_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>decim_factor</value></param>
<param><key>vlen_out</key><value>1</value></param>
</block>
<block>
<key>blocks_min_xx</key>
<param><key>id</key><value>blocks_min_xx_0</value></param>
<param><key>comment</key><value>Noise estimate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size</value></param>
<param><key>vlen_out</key><value>1</value></param>
</block>
<block>
<key>blocks_min_xx</key>
<param><key>id</key><value>blocks_min_xx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>decim_factor</value></param>
<param><key>vlen_out</key><value>1</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>length</key><value>noise_avg</value></param>
<param><key>max_iter</key><value>noise_avg*4</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1.0/noise_avg</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>1/float(sig0_power_avg)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>[1.0/(sig0_p2)]*int(fft_size_sig0/2)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size_sig0/2</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>comment</key><value>to dB</value></param>
<param><key>vlen</key><value>fft_size</value></param>
<param><key>k</key><value>-10*np.log10(fft_size**2)</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>vlen</key><value>fft_size_sig0/2</value></param>
<param><key>k</key><value>-10*np.log10(fft_size_sig0**2)</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size_sig0/4</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size_sig0/4</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0</value></param>
<param><key>comment</key><value>Split / drop FFT edges (to remove filtering artefects)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>4</value></param>
<param><key>vlen</key><value>fft_size_sig0/4</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size_sig0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>2</value></param>
<param><key>vlen</key><value>fft_size_sig0/4</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_2</value></param>
<param><key>comment</key><value>Reduce the feature data</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>decim_factor</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_size_sig0/2/decim_factor</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_2_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_size_sig0/2/decim_factor</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size_sig0/2/decim_factor</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>4</value></param>
<param><key>vlen</key><value>fft_size_sig0/4</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_size_sig0/2</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fft_size_sig0/2</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fft_size)</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0_0</value></param>
<param><key>fft_size</key><value>fft_size_sig0</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(fft_size_sig0)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>inspector_qtgui_sink_vf</key>
<param><key>id</key><value>inspector_qtgui_sink_vf_0</value></param>
<param><key>cfreq</key><value>0</value></param>
<param><key>fft_len</key><value>fft_size</value></param>
<param><key>manual</key><value>False</value></param>
<param><key>msgports</key><value>1</value></param>
<param><key>rf_unit</key><value>1000000</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>inspector_signal_detector_cvf</key>
<param><key>id</key><value>inspector_signal_detector_cvf_0</value></param>
<param><key>auto</key><value>False</value></param>
<param><key>avg</key><value>0.001</value></param>
<param><key>comment</key><value>Signal detection / extraction
(gr-inspector)</value></param>
<param><key>fft_len</key><value>fft_size</value></param>
<param><key>logfile</key><value></value></param>
<param><key>min_bw</key><value>detection_min_bw</value></param>
<param><key>quant</key><value>0.0001</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value> 0.01</value></param>
<param><key>threshold</key><value>energy_threshold</value></param>
<param><key>window</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>inspector_signal_extractor_c</key>
<param><key>id</key><value>inspector_signal_extractor_c_0</value></param>
<param><key>rate</key><value>48000</value></param>
<param><key>osf</key><value>1</value></param>
<param><key>resample</key><value>False</value></param>
<param><key>signal</key><value>0</value></param>
</block>
<block>
<key>inspector_signal_separator_c</key>
<param><key>id</key><value>inspector_signal_separator_c_0</value></param>
<param><key>oversample</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps_file</key><value></value></param>
<param><key>trans_width</key><value>0.1</value></param>
<param><key>file</key><value>False</value></param>
<param><key>window</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>kNNModREC_feature_file_sink</key>
<param><key>id</key><value>kNNModREC_feature_file_sink_0</value></param>
<param><key>capture_button</key><value>capture_now</value></param>
<param><key>file_path</key><value>file_path</value></param>
<param><key>sig_no</key><value>0</value></param>
<param><key>signal_name</key><value>signal_name</value></param>
<param><key>vec_len1</key><value>fft_size_sig0/2/decim_factor</value></param>
<param><key>vec_len2</key><value>fft_size_sig0/2/decim_factor</value></param>
</block>
<block>
<key>kNNModREC_vector_avg</key>
<param><key>id</key><value>kNNModREC_vector_avg_0</value></param>
<param><key>avg_len</key><value>noise_avg</value></param>
<param><key>vec_len</key><value>fft_size</value></param>
</block>
<block>
<key>kNNModREC_vector_avg</key>
<param><key>id</key><value>kNNModREC_vector_avg_0_0_0</value></param>
<param><key>avg_len</key><value>sig0_avg_pts</value></param>
<param><key>vec_len</key><value>fft_size_sig0/2</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>noise_probe</value></param>
<param><key>comment</key><value>noise estimate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>depends on: https://github.com/gnuradio/gr-inspector</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>depends on: </value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>comment</key><value>Used to Creates dataset files.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>comment</key><value>Store extracted Features!</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>bw0</key><value>BW</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>gain</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>14</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>fft_size_sig0/2/decim_factor</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>sig0_p_probe</value></param>
<param><key>comment</key><value>Power estimates of the extracted signal</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>BW</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>comment</key><value>I-Q data</value></param>
<param><key>stream_id</key><value>usrp_out</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>comment</key><value>PSD estimates (not averaged)</value></param>
<param><key>stream_id</key><value>periodogram_inst</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>comment</key><value>Extracted signal
(I-Q data)</value></param>
<param><key>stream_id</key><value>sig_0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_2</value></param>
<param><key>stream_id</key><value>sig_0_fft</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_2_0</value></param>
<param><key>comment</key><value>Extracted Signal (PSD, normalized in power)</value></param>
<param><key>stream_id</key><value>sig_0_psd_normalized</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_2</value></param>
<param><key>stream_id</key><value>map</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>comment</key><value>PSD vector (max held)</value></param>
<param><key>stream_id</key><value>feature_psd_max</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>comment</key><value>PSD vector (min held)</value></param>
<param><key>stream_id</key><value>feature_psd_min</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>comment</key><value>I-Q data from SDR</value></param>
<param><key>stream_id</key><value>usrp_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>comment</key><value>I-Q data</value></param>
<param><key>stream_id</key><value>usrp_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>comment</key><value>Extracted signal (FFTed)</value></param>
<param><key>stream_id</key><value>sig_0_fft</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>comment</key><value>PSD estimates</value></param>
<param><key>stream_id</key><value>periodogram_inst</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs</value></param>
<param><key>comment</key><value>extracted signal</value></param>
<param><key>stream_id</key><value>sig_0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_0</value></param>
<param><key>stream_id</key><value>feature_psd_max</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_0_0</value></param>
<param><key>comment</key><value>PSD of the extracted signal</value></param>
<param><key>stream_id</key><value>sig_0_psd_normalized</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_0_0_0</value></param>
<param><key>stream_id</key><value>map</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vs_0_1</value></param>
<param><key>stream_id</key><value>feature_psd_min</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0</source_block_id><sink_block_id>blocks_stream_to_vector_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_min_xx_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_min_xx_1</source_block_id><sink_block_id>blocks_stream_to_vector_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>noise_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>sig0_p_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_min_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>virtual_sink_0_1_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>fft_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>virtual_sink_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_2</source_block_id><sink_block_id>blocks_max_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_2</source_block_id><sink_block_id>blocks_min_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_2_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_2_0_0</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>kNNModREC_feature_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_stream_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>blocks_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1</source_block_id><sink_block_id>blocks_stream_to_vector_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inspector_qtgui_sink_vf_0</source_block_id><sink_block_id>inspector_signal_separator_c_0</sink_block_id><source_key>map_out</source_key><sink_key>map_in</sink_key></connection>
<connection><source_block_id>inspector_qtgui_sink_vf_0</source_block_id><sink_block_id>virtual_sink_0_2</sink_block_id><source_key>map_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>inspector_signal_detector_cvf_0</source_block_id><sink_block_id>inspector_qtgui_sink_vf_0</sink_block_id><source_key>map_out</source_key><sink_key>map_in</sink_key></connection>
<connection><source_block_id>inspector_signal_detector_cvf_0</source_block_id><sink_block_id>inspector_qtgui_sink_vf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inspector_signal_extractor_c_0</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>inspector_signal_separator_c_0</source_block_id><sink_block_id>inspector_signal_extractor_c_0</sink_block_id><source_key>sig_out</source_key><sink_key>sig_in</sink_key></connection>
<connection><source_block_id>kNNModREC_vector_avg_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kNNModREC_vector_avg_0_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>inspector_signal_detector_cvf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>inspector_signal_separator_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>kNNModREC_vector_avg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vs</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vs_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vs_0</source_block_id><sink_block_id>kNNModREC_feature_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vs_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vs_0_0</source_block_id><sink_block_id>kNNModREC_vector_avg_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vs_0_0_0</source_block_id><sink_block_id>kNNModREC_feature_file_sink_0</sink_block_id><source_key>out</source_key><sink_key>map</sink_key></connection>
<connection><source_block_id>vs_0_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>vs_0_1</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
